# Keil uVision project main.uvprojx, settings and files
target Main (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Class;.\Application;.\Class\DAP;.\Class;.\Core;.\Driver;.\Config
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Application
    ./Application/: main.cpp Test.cpp
  group Class
    ./Class/: dap.c Media.cpp Tag.cpp
  group Driver
    ./Driver/: Lan.cpp GLCD.cpp iap.c
  group Core
    ./Core/: define.h
  group Config
    ./Config/: AddressFlash.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Compiler:I/O:File 1.2.0, File System:CORE 6.13.8, File System:Drive:Memory Card 6.13.8, Network:CORE 7.14.0, Network:Interface:ETH 7.14.0, Network:Socket:TCP 7.14.0, CMSIS Driver:Ethernet MAC 2.12.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
